Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
File name: Project Number
Time: 2023-06-21T16:59:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 21 16:59:45 2023 * Host: LIS-C-00085 * Database: C:\Users\MOA2OVR\AppData\Local\Temp\{5152841C-B4AE-47DD-8F6C-ADF8CA5460D1}\ifc * Database version: 5507 * Database creation date: Wed Jun 21 16:59:43 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Jun 21 16:59:44 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 21 16:59:44 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionControlElement: SmartKey Reader, Intrusion-Products_Bosch_SmartKey_Reader:SmartKey_reader:214675
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: Pr_75_30_30_80 Smart card readers and writers (Uniclass 2015); Material: RAL 9010, Default New Material
Type - Constraints - Default Elevation: 1300 mm
Type - Dimensions - Dimension depth (mm): 30; Dimension height (mm): 80; Dimension width (mm): 80
Type - General - Detection range (max): 20mm; Environmental class: 3; IP Class: IP65; Operating temperature (°C) (maximum): 70; Operating temperature (°C) (minimum): -25
Type - Identity Data - CTN: 4998021692C20; Description: Non-contact reader for SmartKey key; Disclaimer: https://resources-boschsecurity-cdn.azureedge.net/public/information/bim/Disclaimer.pdf; InstallationManual: https://resources-boschsecurity-cdn.azureedge.net/public/documents/4998021692C20_Installation_Manual_enUS_1433784459.pdf; Manufacturer: Bosch Security and Safety Systems; Material number: 4.998.021.692.C20; OmniClass Number: 23.85.30.11.17; OmniClass Title: Electronic Key Systems; PlanningTools: https://resources-boschsecurity-cdn.azureedge.net/public/documents/4998021692C20_Installation_Manual_enUS_1433784459.pdf; Product Information: https://resources-boschsecurity-cdn.azureedge.net/public/documents/SmartKey_reader_Data_sheet_enUS_1433780491.pdf; Product Website: https://commerce.boschsecurity.com/nlexp/en/Recess-mounting-kit-for-SmartKey-reader/p/4.998.021.692.C20/; Type Name: SmartKey_reader
Type - Materials and Finishes - Color: Titanium white; Color in RAL: RAL9010; Material: ASA Luran S
Type - Other - Category: Security Devices; Family Name: Intrusion-Products_Bosch_SmartKey_Reader
Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security and Safety Systems
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Volume: 0.00019607 m3
Identity Data - Mark: 9
Other - 2D_FlippedPosition: yes; 2D_OriginalPosition: no; Family: Intrusion-Products_Bosch_SmartKey_Reader: SmartKey_reader; Family and Type: Intrusion-Products_Bosch_SmartKey_Reader: SmartKey_reader; Schedule Level: Level: Level 1; Type: Intrusion-Products_Bosch_SmartKey_Reader: SmartKey_reader; Type Id: Intrusion-Products_Bosch_SmartKey_Reader: SmartKey_reader
Phasing - Phase Created: New Construction
